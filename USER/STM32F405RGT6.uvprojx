# Keil uVision project STM32F405RGT6.uvprojx, settings and files
target STM32F405RGT6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F405RGT6 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4, __CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --c99
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\LIB;..\USER;..\CORE;..\FWLIB\inc;..\USMART;..\freeRTOS\include;..\freeRTOS\portable\RVDS\ARM_CM4F;..\DSP_LIB\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_it.c main.c
    ../: system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f4xx.s
  group LIB
    ../LIB/: adc.c time5.c LED.c SPI.c iic.c spl06.c AK8975.c bmi088.c filter.c attribute.c upper.c myTask.c SBUS.c GPS.c PWM.c myMath.c dshot.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FREERTOS_CORE
    ../freeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FREERTOS_PROTABLE
    ../freeRTOS/portable/MemMang/: heap_4.c
    ../freeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
